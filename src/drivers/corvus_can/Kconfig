## src/drivers/corvus_can/Kconfig
```kconfig
menuconfig DRIVERS_CORVUS_CAN
	bool "corvus_can"
	default n
	---help---
		Enable support for corvus_can
```
